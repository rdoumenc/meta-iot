require c-ares.inc

SRC_URI = "http://c-ares.haxx.se/download/${PN}-${PV}.tar.gz \
          "

SRC_URI[md5sum] = "d5c6d522cfc54bb6f215a0b7912d46be"
SRC_URI[sha256sum] = "b3612e6617d9682928a1d50c1040de4db6519f977f0b25d40cf1b632900b3efd"

